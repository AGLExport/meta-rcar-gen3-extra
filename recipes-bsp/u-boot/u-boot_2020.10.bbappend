UBOOT_URL = "git://github.com/AGLExport/u-boot.git"
BRANCH = "v2020.10/rcar-5.1.0-erofsdev"

SRCREV = "a4ee20100d10cf08bdf21383fda4963cfcef7a4c"

